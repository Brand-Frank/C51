# Keil uVision project LED-Matrix.uvproj, settings and files
target LED-Matrix (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LED-Matrix +hex
  c flags: Optimize=8 SizeSpeed=1
  group LED-Matrix
    ./: main.c delay.c delay.h Matrix_LED.c Matrix_LED.h
