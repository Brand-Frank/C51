# Keil uVision project Key-LED-status.uvproj, settings and files
target LED (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Key-LED-status +hex
  c flags: Optimize=8 SizeSpeed=1
  group LED
    ./: main.c
