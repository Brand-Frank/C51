# Keil uVision project Buzzer.uvproj, settings and files
target Buzzer (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Buzzer +hex
  c flags: Optimize=8 SizeSpeed=1
  group Buzzer
    ./: main.c delay.c delay.h key.c key.h nixie.c nixie.h buzzer.c buzzer.h
