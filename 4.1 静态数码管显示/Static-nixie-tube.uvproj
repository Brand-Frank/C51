# Keil uVision project Static-nixie-tube.uvproj, settings and files
target STATIC (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Static-nixie-tube +hex
  c flags: Optimize=8 SizeSpeed=1
  group Tube
    ./: mian.c
