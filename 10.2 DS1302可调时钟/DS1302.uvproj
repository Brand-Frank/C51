# Keil uVision project DS1302.uvproj, settings and files
target DS1302 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DS1302 +hex
  c flags: Optimize=8 SizeSpeed=1
  group DS1302
    ./: main.c LCD1602.c LCD1602.h DS1302.c DS1302.h delay.c delay.h key.c key.h Timer0.c Timer0.h
