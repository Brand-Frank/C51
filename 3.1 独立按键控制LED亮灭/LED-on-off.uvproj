# Keil uVision project LED-on-off.uvproj, settings and files
target LED (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LED-on-off +hex
  c flags: Optimize=8 SizeSpeed=1
  group LED-on-off
    ./: main.c
