# Keil uVision project Dynamic-nixie-tube.uvproj, settings and files
target Nixie (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Dynamic-nixie-tube +hex
  c flags: Optimize=8 SizeSpeed=1
  group Nixie
    ./: main.c
