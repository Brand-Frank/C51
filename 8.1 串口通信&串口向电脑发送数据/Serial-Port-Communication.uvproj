# Keil uVision project Serial-Port-Communication.uvproj, settings and files
target Serial-port (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Serial-Port-Communication +hex
  c flags: Optimize=8 SizeSpeed=1
