# Keil uVision project LCD1602.uvproj, settings and files
target LCD1602 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LCD1602 +hex
  c flags: Optimize=8 SizeSpeed=1
  group LCD1602
    ./: main.c LCD1602.c LCD1602.h delay.c delay.h
