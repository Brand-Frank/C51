# Keil uVision project Matrix-keyboard.uvproj, settings and files
target Matrix (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Matrix-keyboard +hex
  c flags: Optimize=8 SizeSpeed=1
  group Matrix
    ./: delay.c delay.h LCD1602.c LCD1602.h main.c MatrixKey.c MatrixKey.h
