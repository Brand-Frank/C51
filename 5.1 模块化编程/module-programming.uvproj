# Keil uVision project module-programming.uvproj, settings and files
target Module (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: module-programming +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\5.1 模块化编程
  group Module
    ./: main.c delay.c nixie.c
