# Keil uVision project LED-flow.uvproj, settings and files
target Timer0 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LED-flow +hex
  c flags: Optimize=8 SizeSpeed=1
  group Timer0
    ./: main.c Timer0.c Timer0.h delay.c delay.h LCD1602.c LCD1602.h
